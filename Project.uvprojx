# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\System;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: MyRTC.c MyRTC.h Delay.c Delay.h sys.c sys.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Data.c OLED_Data.h Encoder.c Encoder.h RP.c RP.h menu.c menu.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h MPU_EXTI.c MPU_EXTI.h MPU6050.c MPU6050.h MPU6050_I2C.c MPU6050_I2C.h pid.c pid.h USART3_WabCam.c USART3_WabCam.h USART4_MPU6050.c USART4_MPU6050.h USART5_Blooteeth.c USART5_Blooteeth.h USART1.c USART1.h USART2.c USART2.h TIM1_Motor.c TIM1_Motor.h TIM1_PWM.c TIM1_PWM.h Buzzer.c Buzzer.h EXTI2_CountSensor.c EXTI12_CountSensor.h DDelay.c DDelay.h Track.c Track.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
